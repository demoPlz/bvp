Commit message: bunch of minor fixes

File: assets/urdf/hands/wxai_base_gripper/wxai_base_gripper_retargeting.urdf (robot description, URDF)
Before this commit: robot wxai_gripper, 7 links, 6 joints
Joints:
- joint right_carriage_joint: mimic joint=left_carriage_joint -> (none)
